# Keil uVision project Automatic-street-light-controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Automatic-street-light-controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Automatic-street-light-controller.c
